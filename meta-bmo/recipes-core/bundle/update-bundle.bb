inherit bundle

RAUC_BUNDLE_COMPATIBLE = "raspberrypi3"

RAUC_BUNDLE_SLOTS = "rootfs"

RAUC_SLOT_rootfs = "bmo-image-ai"

RAUC_BUNDLE_FORMAT = "verity"